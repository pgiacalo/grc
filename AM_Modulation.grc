options:
  parameters:
    comment: |-
      Reference from YouTube video:  
      GNU Radio Amplitude Modulation
      by Tall Paul Tech
      https://www.youtube.com/watch?v=YHND0qWgLM0&t=36s
    generate_options: qt_gui
    id: AM_Modulation
    output_language: python
    title: AM Modulation
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 1
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '2'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Baseband
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      We add 1 to the baseband signal so that the resulting values are always positive (between zero and 2). 
      This yeilds a multiply result that maintains the phase of the AM modulated output. 
      Otherwise, the phase would shift / invert with every cycle of the baseband signal.
      We don't want the phase to shift.
    const: '1'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: Divide by 2 so the resulting Baseband signal is between zero and one
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 'Modulated Result: Multiplying the carrier and baseband yields an AM modulated signal.'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: bb_gain
    comment: 27.185 MHz is a CB radio band
    freq0: 27.185e6
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: tx_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Carrier
    label2: Baseband
    label3: Modulated
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(tx_samp_rate / samp_rate)
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: To_Transmitter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: To_Transmitter
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_const_vxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '0']
- [audio_source_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
