options:
  parameters:
    generate_options: qt_gui
    id: GreatScottLesson1
    output_language: python
    title: GreatScottLesson1
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: bb_gain
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Set the center frequency to the mid point of the band.
      In the case of the FM band, this is 98MHz (the full range is 88 to 108 MHz).
    value: 98.0e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    comment: Set this value to the desired channel frequency.
    value: tuning
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if_gain
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: output_gain
  id: variable_qtgui_range
  parameters:
    label: output_gain
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The maximum sample rate for the HackRF = 20M samples/second. 
      However, using the maximum value could bog down the CPU.
    value: 20e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Tuning
    start: 88e6
    step: 0.1e6
    stop: 108e6
    value: 102.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: output_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf"'
    bb_gain0: bb_gain
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
