options:
  parameters:
    generate_options: qt_gui
    id: Receive2_4_GHz
    output_language: python
    title: Receive2_4_GHz
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Set the center frequency to the mid point of the band.
      In the case of the FM band, this is 98MHz (the full range is 88 to 108 MHz).
    value: center_frequency
  states: {}
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 10e6
    stop: 500e6
    value: 10e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The maximum sample rate for the HackRF = 20M samples/second. 
      However, using the maximum value could bog down the CPU.
    value: 20e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf"'
    bb_gain0: '10'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    name: '"Sink"'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
